# Keil uVision project BOOSTXL-SENSORS_SensorGUI_MSP432P401R.uvprojx, settings and files
target BOOSTXL-SENSORS_SensorGUI_MSP432P401R (5060020::V5.06 (build 20)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.1.1
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOSTXL-SENSORS_SensorGUI_MSP432P401R
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..;..\driverlib\MSP432P4xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ../src/: bme280.c bme280_support.c bmi160.c bmi160_support.c demo_sysctl.c i2c_driver.c main.c opt3001.c tmp007.c uart_driver.c
  group driverlib
    ../driverlib/MSP432P4xx/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
software components: CMSIS:CORE 4.2.0, Device:Startup 2.1.0
