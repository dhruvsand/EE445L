<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BOOSTXL-K350QVG-S1_GrlibExample_MSP432P401R.ewp</path>
  </project>
  <batchBuild/>
</workspace>


