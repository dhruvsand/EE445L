<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\430BOOST-SENSE1_CapTouch_MSP432P401R.ewp</path>
  </project>
  <batchBuild/>
</workspace>


