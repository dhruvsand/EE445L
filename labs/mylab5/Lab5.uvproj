# Keil uVision project Lab5.uvproj, settings and files
target Lab5 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab5
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Timer0A.c PLL.c Main.c DAC.c Music.c SysTick.c DAC.h Music.h PLL.h Switch.h SysTick.h Timer0A.h Timer1A.c Timer1A.h Buttons.h Buttons.c Timer2A.c Timer2A.h
