# Keil uVision project LCDTest.uvproj, settings and files
target LCDTest (ARM-ADS)
  device: TM4C1233H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCDTest
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --fpu=fpv4-sp --c99
  c include: ..;..\..\..
  asm include: ../
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c SSD2119.c random.s LCDTestMain.c Nokia5110.c Tiva_Accelerometer.c Tiva_i2c.c ADXL345_Accelerometer.c ADXL345_Accelerometer.h Nokia5110.h Tiva_i2c.h
